# Keil uVision project UVFrameworkHSMTemplate.uvprojx, settings and files
target BaseFrameworkTarget (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Main
    ./Source/: HSMTemplateMain.c
  group Source
    ./Source/: EventCheckers.c ADMulti.c CitySensorHW.c EnablePA25_PB23_PD7_PF0.c EventPrinter.c IRSensorHW.c LEDsHW.c LineSensorsHW.c MasterSM.c SSIHW.c TeamColorSwitchHW.c BotSM.c GameTimerSM.c PACCommSM.c AtCityCommSM.c CAMMotorHW.c SwitchesHW.c MapKeys.c AtCityShootSM.c FindingCityNavSM.c Project_MotorService.c Project_PWMlab.c PeriodicEventCheckerService.c PWMServo.c
  group Headers
    ./Headers/: uartstdio.h Bin_Const.h BITDEFS.H ES_CheckEvents.h ES_Configure.h ES_DeferRecall.h ES_Events.h ES_Framework.h ES_General.h ES_LookupTables.h ES_Port.h ES_PostList.h ES_PriorTables.h ES_Queue.h ES_ServiceHeaders.h ES_Timers.h ES_Types.h EventCheckers.h termio.h MapKeys.h ADMulti.h CitySensorHW.h EnablePA25_PB23_PD7_PF0.h EventPrinter.h IRSensorHW.h LEDsHW.h LineSensorsHW.h MasterSM.h SSIHW.h TeamColorSwitchHW.h BotSM.h HSMTemplate.h GameTimerSM.h PACCommSM.h AtCityCommSM.h SwitchesHW.h CAMMotorHW.h AtCityShootSM.h FindingCityNavSM.h Project_MotorService.h Project_PWMlab.h PeriodicEventCheckerService.h PWMServo.h
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
  group Startup
    ./StartUp/: startup_rvmdk.S
  group Framework
    ./Source/: ES_CheckEvents.c ES_DeferRecall.c ES_Framework.c ES_LookupTables.c ES_Port.c ES_PostList.c ES_Queue.c ES_Timers.c retarget.c termio.c uartstdio.c
software components: CMSIS:CORE 4.3.0
